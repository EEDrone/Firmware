# Keil uVision project EEDrone.uvprojx, settings and files
target EEDrone (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: EEDrone
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: udp.c raw.c tcp_out.c mem.c stats.c init.c pbuf.c tcp.c tcp_in.c lwip_timers.c dns.c memp.c inet_chksum.c netif.c sys.c def.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: chap-new.c pppcrypt.c pppol2tp.c ipcp.c ccp.c multilink.c ecp.c utils.c pppoe.c vj.c pppos.c chap-md5.c auth.c eap.c ppp.c chap_ms.c demand.c mppe.c lcp.c fsm.c ipv6cp.c eui64.c upap.c magic.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: nd6.c mld6.c ip6_frag.c ip6.c inet6.c icmp6.c dhcp6.c ethip6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c api_lib.c api_msg.c pppapi.c netbuf.c netdb.c netifapi.c tcpip.c sockets.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c sha1.c md4.c des.c arc4.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c dhcp.c ip4_addr.c ip_frag.c igmp.c ip4.c autoip.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_i2c.c stm32f7xx_hal_uart.c stm32f7xx_hal_eth.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pcd.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_sd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_adc.c stm32f7xx_hal_sai.c stm32f7xx_hal_qspi.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_sai_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: fatfs.c lwip.c freertos.c bsp_driver_sd.c usbd_conf.c usbd_cdc_if.c usb_device.c usbd_desc.c ethernetif.c main.c stm32f7xx_it.c stm32f7xx_hal_msp.c i2c.c usart.c tim.c can.c spi.c adc.c sai.c sdmmc.c gpio.c quadspi.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c croutine.c timers.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
software components: CMSIS:CORE 4.1.0
